*Values:  95815
*R1 = 1.04606282456
*R2 = 2.00732621328
*R3 = 3.06060705885
*R4 = 4.07055531265
*R5 = 3.1225213804
*R6 = 2.06927045958
*R7 = 1.01531018068
*Va = 5.24359648479
*Id = 1.01891541651
*Kb = 7.0473187437
*Kc = 8.3479788681
*-------------------------------------------------------
* NGSPICE simulation script
* BJT amp with feedback
*

* forces current values to be saved
.options savecurrents

*resistors
R1 2 1 1.04606282456
R2 3 2 2.00732621328
R3 2 4 3.06060705885
R4 4 0 4.07055531265
R5 5 4 3.1225213804
R6 8 0 2.06927045958
R7 6 7 1.01531018068

*independent voltage and current sources
Va 1 0 DC 5.24359648479

Id 6 5 DC 1.01891541651

Vf 8 7 DC 0

*dependent voltage and current sources
Hc 4 6 Vf 8.3479788681

Gb 5 3 2 4 7.0473187437

.control

*makes plots in color
set hcopypscolor=0
set color0=white
set color1=black
set color2=red
set color3=blue
set color4=violet
set color5=rgb:3/8/0
set color6=rgb:4/0/0

op

echo "********************************************"
echo  "Operating point"
echo "********************************************"
print v-sweep
print @R6[i]

echo  "op_TAB"
print all
echo  "op_END"

quit
.endc

.end
